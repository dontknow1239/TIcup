# Keil uVision project Velocity.uvprojx, settings and files
target Balance (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Balance +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\CMSIS;..\FWLib\inc;..\USER;..\BSP\Battery;..\BSP\Beep;..\BSP;..\BSP\Bluetooth;..\BSP\Delay;..\BSP\Encoder;..\BSP\IRtracking;..\BSP\K210;..\BSP\Key;..\BSP\LED;..\BSP\Motor;..\BSP\MPU6050;..\BSP\MPU6050\DMP;..\BSP\MPU6050\IIC_Software;..\BSP\OLED;..\BSP\Timer;..\BSP\Usart1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c AllHeader.h myenum.h
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/Battery/: bsp_battery.c
    ../BSP/Beep/: bsp_beep.c
    ../BSP/Bluetooth/: bsp_bluetooth.c
    ../BSP/Delay/: delay.c
    ../BSP/Encoder/: encoder.c
    ../BSP/IRtracking/: bsp_irtracking.c
    ../BSP/K210/: bsp_k210.c bsp_usart2.c
    ../BSP/Key/: bsp_key.c
    ../BSP/LED/: bsp_LED.c
    ../BSP/Motor/: motor.c
    ../BSP/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BSP/MPU6050/IIC_Software/: IOI2C.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/OLED/: bsp_oled.c bsp_oled_i2c.c oled_fonts.c
    ../BSP/Timer/: bsp_timer.c
    ../BSP/Usart1/: usart.c
    ../BSP/: bsp.c
